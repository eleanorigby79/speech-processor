# Keil uVision project arm_cortexM4lf_graphic_equalizer_example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: arm_cortexM4lf_graphic_equalizer_example
  c flags: Optim=3 oTime=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\..\..\..\Include;..\..\Common\Include;..\..\..\..\..\Device\ARM\ARMCM4\Include
  group Source Group 1
    ../: arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c
    ../../Common/Source/: math_helper.c
  group CMSIS Device
    ../: system_ARMCM4.c
    ./: startup_ARMCM4.s
  group CMSIS DSP_Library
    ../../../../Lib/ARM/: arm_cortexM4lf_math.lib
